# Keil uVision project rosserial_mbed_hello_world_publisher.uvprojx, settings and files
target rosserial_mbed_hello_world_publisher (ARM-ADS)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: rosserial_mbed_hello_world_publisher
  c flags: Optim=2 uC99=1
  c misc: -DDEVICE_RTC=1 -DDEVICE_SLEEP=1 -DTOOLCHAIN_object -DTOOLCHAIN_ARM_STD -DTARGET_STM32F407 --preinclude=mbed_config.h -DTARGET_STM32F4 -D__ASSERT_MSG -DTARGET_RELEASE --no_rtti -Otime -DDEVICE_PORTINOUT=1 -DTARGET_FF_ARDUINO -c -DTARGET_RTOS_M4_M7 -O3 -DTARGET_ARCH_MAX -DDEVICE_SPISLAVE=1 -DDEVICE_PORTOUT=1 -DDEVICE_STDIO_MESSAGES=1 -DDEVICE_ANALOGOUT=1 --split_sections --cpu=Cortex-M4.fp -DDEVICE_SERIAL=1 -DDEVICE_ANALOGIN=1 -DTARGET_LIKE_CORTEX_M4 -D__CORTEX_M4 -DTARGET_CORTEX_M -DARM_MATH_CM4 -DDEVICE_I2C=1 -DDEVICE_PORTIN=1 -DTARGET_STM -DTOOLCHAIN_ARM -DDEVICE_INTERRUPTIN=1 -DLSI_VALUE=32000 --no_depend_system_headers -DTARGET_UVISOR_UNSUPPORTED --md -DDEVICE_PWMOUT=1 -DTARGET_LIKE_MBED --gnu --apcs=interwork -DDEVICE_SPI=1 -D__MBED__=1 -DTARGET_STM32F407VG -DTARGET_M4 -D__FPU_PRESENT=1 -DDEVICE_I2CSLAVE=1 -D__CMSIS_RTOS -DMBED_BUILD_TIMESTAMP=1476189199.32 -D__MBED_CMSIS_RTOS_CM
  c include: .; ros_lib_indigo; ros_lib_indigo/actionlib; ros_lib_indigo/actionlib_msgs; ros_lib_indigo/actionlib_tutorials; ros_lib_indigo/bond; ros_lib_indigo/control_msgs; ros_lib_indigo/diagnostic_msgs; ros_lib_indigo/driver_base; ros_lib_indigo/dynamic_reconfigure; ros_lib_indigo/gazebo_msgs; ros_lib_indigo/geometry_msgs; ros_lib_indigo/laser_assembler; ros_lib_indigo/map_msgs; ros_lib_indigo/nav_msgs; ros_lib_indigo/nodelet; ros_lib_indigo/opencv_apps; ros_lib_indigo/pcl_msgs; ros_lib_indigo/polled_camera; ros_lib_indigo/ros; ros_lib_indigo/roscpp; ros_lib_indigo/roscpp_tutorials; ros_lib_indigo/rosgraph_msgs; ros_lib_indigo/rospy_tutorials; ros_lib_indigo/rosserial_mbed; ros_lib_indigo/rosserial_msgs; ros_lib_indigo/sensor_msgs; ros_lib_indigo/shape_msgs; ros_lib_indigo/smach_msgs; ros_lib_indigo/std_msgs; ros_lib_indigo/std_srvs; ros_lib_indigo/stereo_msgs; ros_lib_indigo/tf; ros_lib_indigo/tf2_msgs; ros_lib_indigo/theora_image_transport; ros_lib_indigo/topic_tools; ros_lib_indigo/trajectory_msgs; ros_lib_indigo/turtle_actionlib; ros_lib_indigo/turtlesim; ros_lib_indigo/visualization_msgs; ros_lib_indigo/BufferedSerial; ros_lib_indigo/BufferedSerial/Buffer; mbed/.; mbed/TARGET_ARCH_MAX; mbed/TARGET_ARCH_MAX/TARGET_STM; mbed/TARGET_ARCH_MAX/TARGET_STM/TARGET_STM32F4; mbed/TARGET_ARCH_MAX/TARGET_STM/TARGET_STM32F4/TARGET_ARCH_MAX; mbed/TARGET_ARCH_MAX/TOOLCHAIN_ARM_STD
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-D__CORTEX_M4,-D__FPU_PRESENT=1,-DLSI_VALUE=32000,-DARM_MATH_CM4,-D__CMSIS_RTOS,-D__MBED_CMSIS_RTOS_CM
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: mbed/TARGET_ARCH_MAX/TOOLCHAIN_ARM_STD/STM32F407.sct
  group Buffer
    ros_lib_indigo/BufferedSerial/Buffer/: MyBuffer.cpp MyBuffer.h
  group BufferedSerial
    ros_lib_indigo/BufferedSerial/: BufferedSerial.cpp BufferedSerial.h
  group TARGET_ARCH_MAX
    mbed/TARGET_ARCH_MAX/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis.h cmsis_nvic.h core_ca9.h core_ca_mmu.h core_caFunc.h core_caInstr.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm4_simd.h core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSimd.h core_sc000.h core_sc300.h hal_tick.h stm32_hal_legacy.h stm32f407xx.h stm32f4xx.h stm32f4xx_hal.h stm32f4xx_hal_adc.h stm32f4xx_hal_adc_ex.h stm32f4xx_hal_can.h stm32f4xx_hal_cec.h stm32f4xx_hal_conf.h stm32f4xx_hal_conf_template.h stm32f4xx_hal_cortex.h stm32f4xx_hal_crc.h stm32f4xx_hal_cryp.h stm32f4xx_hal_cryp_ex.h stm32f4xx_hal_dac.h stm32f4xx_hal_dac_ex.h stm32f4xx_hal_dcmi.h stm32f4xx_hal_dcmi_ex.h stm32f4xx_hal_def.h stm32f4xx_hal_dma.h stm32f4xx_hal_dma2d.h stm32f4xx_hal_dma_ex.h stm32f4xx_hal_dsi.h stm32f4xx_hal_eth.h stm32f4xx_hal_flash.h stm32f4xx_hal_flash_ex.h stm32f4xx_hal_flash_ramfunc.h stm32f4xx_hal_fmpi2c.h stm32f4xx_hal_fmpi2c_ex.h stm32f4xx_hal_gpio.h stm32f4xx_hal_gpio_ex.h stm32f4xx_hal_hash.h stm32f4xx_hal_hash_ex.h stm32f4xx_hal_hcd.h stm32f4xx_hal_i2c.h stm32f4xx_hal_i2c_ex.h stm32f4xx_hal_i2s.h stm32f4xx_hal_i2s_ex.h stm32f4xx_hal_irda.h stm32f4xx_hal_iwdg.h stm32f4xx_hal_lptim.h stm32f4xx_hal_ltdc.h stm32f4xx_hal_ltdc_ex.h stm32f4xx_hal_nand.h stm32f4xx_hal_nor.h stm32f4xx_hal_pccard.h stm32f4xx_hal_pcd.h stm32f4xx_hal_pcd_ex.h stm32f4xx_hal_pwr.h stm32f4xx_hal_pwr_ex.h stm32f4xx_hal_qspi.h stm32f4xx_hal_rcc.h stm32f4xx_hal_rcc_ex.h stm32f4xx_hal_rng.h stm32f4xx_hal_rtc.h stm32f4xx_hal_rtc_ex.h stm32f4xx_hal_sai.h stm32f4xx_hal_sai_ex.h stm32f4xx_hal_sd.h stm32f4xx_hal_sdram.h stm32f4xx_hal_smartcard.h stm32f4xx_hal_spdifrx.h stm32f4xx_hal_spi.h stm32f4xx_hal_sram.h stm32f4xx_hal_tim.h stm32f4xx_hal_tim_ex.h stm32f4xx_hal_uart.h stm32f4xx_hal_usart.h stm32f4xx_hal_wwdg.h stm32f4xx_ll_fmc.h stm32f4xx_ll_fsmc.h stm32f4xx_ll_sdmmc.h stm32f4xx_ll_usb.h system_stm32f4xx.h
    mbed/TARGET_ARCH_MAX/TARGET_STM/TARGET_STM32F4/TARGET_ARCH_MAX/: device.h objects.h PeripheralNames.h PinNames.h PortNames.h
  group TARGET_STM32F4
    mbed/TARGET_ARCH_MAX/TARGET_STM/TARGET_STM32F4/: gpio_object.h PeripheralPins.h
  group TOOLCHAIN_ARM_STD
    mbed/TARGET_ARCH_MAX/TOOLCHAIN_ARM_STD/: board.o cmsis_nvic.o hal_tick.o mbed.ar mbed_overrides.o retarget.o startup_STM32F40x.o stm32f4xx_hal.o stm32f4xx_hal_adc.o stm32f4xx_hal_adc_ex.o stm32f4xx_hal_can.o stm32f4xx_hal_cec.o stm32f4xx_hal_cortex.o stm32f4xx_hal_crc.o stm32f4xx_hal_cryp.o stm32f4xx_hal_cryp_ex.o stm32f4xx_hal_dac.o stm32f4xx_hal_dac_ex.o stm32f4xx_hal_dcmi.o stm32f4xx_hal_dcmi_ex.o stm32f4xx_hal_dma.o stm32f4xx_hal_dma2d.o stm32f4xx_hal_dma_ex.o stm32f4xx_hal_dsi.o stm32f4xx_hal_eth.o stm32f4xx_hal_flash.o stm32f4xx_hal_flash_ex.o stm32f4xx_hal_flash_ramfunc.o stm32f4xx_hal_fmpi2c.o stm32f4xx_hal_fmpi2c_ex.o stm32f4xx_hal_gpio.o stm32f4xx_hal_hash.o stm32f4xx_hal_hash_ex.o stm32f4xx_hal_hcd.o stm32f4xx_hal_i2c.o stm32f4xx_hal_i2c_ex.o stm32f4xx_hal_i2s.o stm32f4xx_hal_i2s_ex.o stm32f4xx_hal_irda.o stm32f4xx_hal_iwdg.o stm32f4xx_hal_lptim.o stm32f4xx_hal_ltdc.o stm32f4xx_hal_ltdc_ex.o stm32f4xx_hal_msp_template.o stm32f4xx_hal_nand.o stm32f4xx_hal_nor.o stm32f4xx_hal_pccard.o stm32f4xx_hal_pcd.o stm32f4xx_hal_pcd_ex.o stm32f4xx_hal_pwr.o stm32f4xx_hal_pwr_ex.o stm32f4xx_hal_qspi.o stm32f4xx_hal_rcc.o stm32f4xx_hal_rcc_ex.o stm32f4xx_hal_rng.o stm32f4xx_hal_rtc.o stm32f4xx_hal_rtc_ex.o stm32f4xx_hal_sai.o stm32f4xx_hal_sai_ex.o stm32f4xx_hal_sd.o stm32f4xx_hal_sdram.o stm32f4xx_hal_smartcard.o stm32f4xx_hal_spdifrx.o stm32f4xx_hal_spi.o stm32f4xx_hal_sram.o stm32f4xx_hal_tim.o stm32f4xx_hal_tim_ex.o stm32f4xx_hal_uart.o stm32f4xx_hal_usart.o stm32f4xx_hal_wwdg.o stm32f4xx_ll_fmc.o stm32f4xx_ll_fsmc.o stm32f4xx_ll_sdmmc.o stm32f4xx_ll_usb.o sys.o system_stm32f4xx.o
  group actionlib
    ros_lib_indigo/actionlib/: TestAction.h TestActionFeedback.h TestActionGoal.h TestActionResult.h TestFeedback.h TestGoal.h TestRequestAction.h TestRequestActionFeedback.h TestRequestActionGoal.h TestRequestActionResult.h TestRequestFeedback.h TestRequestGoal.h TestRequestResult.h TestResult.h TwoIntsAction.h TwoIntsActionFeedback.h TwoIntsActionGoal.h TwoIntsActionResult.h TwoIntsFeedback.h TwoIntsGoal.h TwoIntsResult.h
  group actionlib_msgs
    ros_lib_indigo/actionlib_msgs/: GoalID.h GoalStatus.h GoalStatusArray.h
  group actionlib_tutorials
    ros_lib_indigo/actionlib_tutorials/: AveragingAction.h AveragingActionFeedback.h AveragingActionGoal.h AveragingActionResult.h AveragingFeedback.h AveragingGoal.h AveragingResult.h FibonacciAction.h FibonacciActionFeedback.h FibonacciActionGoal.h FibonacciActionResult.h FibonacciFeedback.h FibonacciGoal.h FibonacciResult.h
  group bond
    ros_lib_indigo/bond/: Constants.h Status.h
  group control_msgs
    ros_lib_indigo/control_msgs/: FollowJointTrajectoryAction.h FollowJointTrajectoryActionFeedback.h FollowJointTrajectoryActionGoal.h FollowJointTrajectoryActionResult.h FollowJointTrajectoryFeedback.h FollowJointTrajectoryGoal.h FollowJointTrajectoryResult.h GripperCommand.h GripperCommandAction.h GripperCommandActionFeedback.h GripperCommandActionGoal.h GripperCommandActionResult.h GripperCommandFeedback.h GripperCommandGoal.h GripperCommandResult.h JointControllerState.h JointTolerance.h JointTrajectoryAction.h JointTrajectoryActionFeedback.h JointTrajectoryActionGoal.h JointTrajectoryActionResult.h JointTrajectoryControllerState.h JointTrajectoryFeedback.h JointTrajectoryGoal.h JointTrajectoryResult.h PointHeadAction.h PointHeadActionFeedback.h PointHeadActionGoal.h PointHeadActionResult.h PointHeadFeedback.h PointHeadGoal.h PointHeadResult.h QueryCalibrationState.h QueryTrajectoryState.h SingleJointPositionAction.h SingleJointPositionActionFeedback.h SingleJointPositionActionGoal.h SingleJointPositionActionResult.h SingleJointPositionFeedback.h SingleJointPositionGoal.h SingleJointPositionResult.h
  group diagnostic_msgs
    ros_lib_indigo/diagnostic_msgs/: DiagnosticArray.h DiagnosticStatus.h KeyValue.h SelfTest.h
  group driver_base
    ros_lib_indigo/driver_base/: ConfigString.h ConfigValue.h SensorLevels.h
  group dynamic_reconfigure
    ros_lib_indigo/dynamic_reconfigure/: BoolParameter.h Config.h ConfigDescription.h DoubleParameter.h Group.h GroupState.h IntParameter.h ParamDescription.h Reconfigure.h SensorLevels.h StrParameter.h
  group gazebo_msgs
    ros_lib_indigo/gazebo_msgs/: ApplyBodyWrench.h ApplyJointEffort.h BodyRequest.h ContactsState.h ContactState.h DeleteModel.h GetJointProperties.h GetLinkProperties.h GetLinkState.h GetModelProperties.h GetModelState.h GetPhysicsProperties.h GetWorldProperties.h JointRequest.h LinkState.h LinkStates.h ModelState.h ModelStates.h ODEJointProperties.h ODEPhysics.h SetJointProperties.h SetJointTrajectory.h SetLinkProperties.h SetLinkState.h SetModelConfiguration.h SetModelState.h SetPhysicsProperties.h SpawnModel.h WorldState.h
  group geometry_msgs
    ros_lib_indigo/geometry_msgs/: Accel.h AccelStamped.h AccelWithCovariance.h AccelWithCovarianceStamped.h Inertia.h InertiaStamped.h Point.h Point32.h PointStamped.h Polygon.h PolygonStamped.h Pose.h Pose2D.h PoseArray.h PoseStamped.h PoseWithCovariance.h PoseWithCovarianceStamped.h Quaternion.h QuaternionStamped.h Transform.h TransformStamped.h Twist.h TwistStamped.h TwistWithCovariance.h TwistWithCovarianceStamped.h Vector3.h Vector3Stamped.h Wrench.h WrenchStamped.h
  group laser_assembler
    ros_lib_indigo/laser_assembler/: AssembleScans.h AssembleScans2.h
  group map_msgs
    ros_lib_indigo/map_msgs/: GetMapROI.h GetPointMap.h GetPointMapROI.h OccupancyGridUpdate.h PointCloud2Update.h ProjectedMap.h ProjectedMapInfo.h ProjectedMapsInfo.h SaveMap.h SetMapProjections.h
  group mbed
    mbed/: AnalogIn.h analogin_api.h AnalogOut.h analogout_api.h buffer.h BusIn.h BusInOut.h BusOut.h CallChain.h CAN.h can_api.h can_helper.h CircularBuffer.h CThunk.h DigitalIn.h DigitalInOut.h DigitalOut.h DirHandle.h dma_api.h Ethernet.h ethernet_api.h FileBase.h FileHandle.h FileLike.h FilePath.h FileSystemLike.h FunctionPointer.h gpio_api.h gpio_irq_api.h I2C.h i2c_api.h I2CSlave.h InterruptIn.h InterruptManager.h LocalFileSystem.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h lp_ticker_api.h mbed.h mbed_assert.h mbed_debug.h mbed_error.h mbed_interface.h pinmap.h platform.h port_api.h PortIn.h PortInOut.h PortOut.h PwmOut.h pwmout_api.h RawSerial.h rtc_api.h rtc_time.h semihost_api.h Serial.h serial_api.h SerialBase.h sleep_api.h SPI.h spi_api.h SPISlave.h Stream.h Ticker.h ticker_api.h Timeout.h Timer.h TimerEvent.h toolchain.h Transaction.h us_ticker_api.h wait_api.h
  group nav_msgs
    ros_lib_indigo/nav_msgs/: GetMap.h GetMapAction.h GetMapActionFeedback.h GetMapActionGoal.h GetMapActionResult.h GetMapFeedback.h GetMapGoal.h GetMapResult.h GetPlan.h GridCells.h MapMetaData.h OccupancyGrid.h Odometry.h Path.h SetMap.h
  group nodelet
    ros_lib_indigo/nodelet/: NodeletList.h NodeletLoad.h NodeletUnload.h
  group opencv_apps
    ros_lib_indigo/opencv_apps/: Circle.h CircleArray.h CircleArrayStamped.h Contour.h ContourArray.h ContourArrayStamped.h Face.h FaceArray.h FaceArrayStamped.h Flow.h FlowArray.h FlowArrayStamped.h FlowStamped.h Line.h LineArray.h LineArrayStamped.h Moment.h MomentArray.h MomentArrayStamped.h Point2D.h Point2DArray.h Point2DArrayStamped.h Point2DStamped.h Rect.h RectArray.h RectArrayStamped.h RotatedRect.h RotatedRectArray.h RotatedRectArrayStamped.h RotatedRectStamped.h Size.h
  group pcl_msgs
    ros_lib_indigo/pcl_msgs/: ModelCoefficients.h PointIndices.h PolygonMesh.h Vertices.h
  group polled_camera
    ros_lib_indigo/polled_camera/: GetPolledImage.h
  group ros
    ros_lib_indigo/ros/: duration.h msg.h node_handle.h publisher.h service_client.h service_server.h subscriber.h time.h
  group ros_lib_indigo
    ros_lib_indigo/: duration.cpp MbedHardware.h ros.h time.cpp
  group roscpp
    ros_lib_indigo/roscpp/: Empty.h GetLoggers.h Logger.h SetLoggerLevel.h
  group roscpp_tutorials
    ros_lib_indigo/roscpp_tutorials/: TwoInts.h
  group rosgraph_msgs
    ros_lib_indigo/rosgraph_msgs/: Clock.h Log.h TopicStatistics.h
  group rospy_tutorials
    ros_lib_indigo/rospy_tutorials/: AddTwoInts.h BadTwoInts.h Floats.h HeaderString.h
  group rosserial_mbed
    ros_lib_indigo/rosserial_mbed/: Adc.h Test.h
  group rosserial_mbed_hello_world_publisher
    ./: main.cpp mbed_config.h
  group rosserial_msgs
    ros_lib_indigo/rosserial_msgs/: Log.h RequestMessageInfo.h RequestParam.h RequestServiceInfo.h TopicInfo.h
  group sensor_msgs
    ros_lib_indigo/sensor_msgs/: CameraInfo.h ChannelFloat32.h CompressedImage.h FluidPressure.h Illuminance.h Image.h Imu.h JointState.h Joy.h JoyFeedback.h JoyFeedbackArray.h LaserEcho.h LaserScan.h MagneticField.h MultiDOFJointState.h MultiEchoLaserScan.h NavSatFix.h NavSatStatus.h PointCloud.h PointCloud2.h PointField.h Range.h RegionOfInterest.h RelativeHumidity.h SetCameraInfo.h Temperature.h TimeReference.h
  group shape_msgs
    ros_lib_indigo/shape_msgs/: Mesh.h MeshTriangle.h Plane.h SolidPrimitive.h
  group smach_msgs
    ros_lib_indigo/smach_msgs/: SmachContainerInitialStatusCmd.h SmachContainerStatus.h SmachContainerStructure.h
  group std_msgs
    ros_lib_indigo/std_msgs/: Bool.h Byte.h ByteMultiArray.h Char.h ColorRGBA.h Duration.h Empty.h Float32.h Float32MultiArray.h Float64.h Float64MultiArray.h Header.h Int16.h Int16MultiArray.h Int32.h Int32MultiArray.h Int64.h Int64MultiArray.h Int8.h Int8MultiArray.h MultiArrayDimension.h MultiArrayLayout.h String.h Time.h UInt16.h UInt16MultiArray.h UInt32.h UInt32MultiArray.h UInt64.h UInt64MultiArray.h UInt8.h UInt8MultiArray.h
  group std_srvs
    ros_lib_indigo/std_srvs/: Empty.h Trigger.h
  group stereo_msgs
    ros_lib_indigo/stereo_msgs/: DisparityImage.h
  group tf
    ros_lib_indigo/tf/: FrameGraph.h tf.h tfMessage.h transform_broadcaster.h
  group tf2_msgs
    ros_lib_indigo/tf2_msgs/: FrameGraph.h LookupTransformAction.h LookupTransformActionFeedback.h LookupTransformActionGoal.h LookupTransformActionResult.h LookupTransformFeedback.h LookupTransformGoal.h LookupTransformResult.h TF2Error.h TFMessage.h
  group theora_image_transport
    ros_lib_indigo/theora_image_transport/: Packet.h
  group topic_tools
    ros_lib_indigo/topic_tools/: DemuxAdd.h DemuxDelete.h DemuxList.h DemuxSelect.h MuxAdd.h MuxDelete.h MuxList.h MuxSelect.h
  group trajectory_msgs
    ros_lib_indigo/trajectory_msgs/: JointTrajectory.h JointTrajectoryPoint.h MultiDOFJointTrajectory.h MultiDOFJointTrajectoryPoint.h
  group turtle_actionlib
    ros_lib_indigo/turtle_actionlib/: ShapeAction.h ShapeActionFeedback.h ShapeActionGoal.h ShapeActionResult.h ShapeFeedback.h ShapeGoal.h ShapeResult.h Velocity.h
  group turtlesim
    ros_lib_indigo/turtlesim/: Color.h Kill.h Pose.h SetPen.h Spawn.h TeleportAbsolute.h TeleportRelative.h
  group visualization_msgs
    ros_lib_indigo/visualization_msgs/: ImageMarker.h InteractiveMarker.h InteractiveMarkerControl.h InteractiveMarkerFeedback.h InteractiveMarkerInit.h InteractiveMarkerPose.h InteractiveMarkerUpdate.h Marker.h MarkerArray.h MenuEntry.h
